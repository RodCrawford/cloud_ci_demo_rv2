# Keil uVision project CMSIS_RV2.uvprojx, settings and files
target Debug (6150000::V6.15::ARMCLANG)
  device: ARMCM55 ARM
  pack: ARM.CMSIS.5.7.1-dev1
  cpu: IRAM(0x30000000,0x00020000) IRAM2(0x20000000,0x00020000) IROM(0x10000000,0x00200000) IROM2(0x00000000,0x00200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: CMSIS-RV2
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  asm include: .\RTE\_Debug
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\RTE\Device\ARMCM55\ARMCM55_ac6.sct
  group Documents
    ./: Abstract.txt
  group Source
    ./: main.c
software components: CMSIS RTOS2 Validation:EventFlags 1.0.0, CMSIS RTOS2 Validation:Framework 1.0.1, CMSIS RTOS2 Validation:GenWait 1.0.0, CMSIS RTOS2 Validation:Kernel 1.0.0, CMSIS RTOS2 Validation:MemoryPool 1.0.0, CMSIS RTOS2 Validation:MsgQueue 1.0.0, CMSIS RTOS2 Validation:Mutex 1.0.0, CMSIS RTOS2 Validation:Semaphore 1.0.0, CMSIS RTOS2 Validation:Thread 1.0.0, CMSIS RTOS2 Validation:ThreadFlags 1.0.0, CMSIS RTOS2 Validation:Timer 1.0.0, CMSIS:CORE 5.4.0, CMSIS:RTOS2:Keil RTX5 5.5.2, Device:Startup 1.1.0
